options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: samp_rate*1
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: rswaveforms_smu_waveform_sink_0
  id: rswaveforms_smu_waveform_sink
  parameters:
    filename: cosine_new.wv
    samp_rate: samp_rate
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_head_0, '0', rswaveforms_smu_waveform_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_head_0, '0']
- [blocks_throttle_0, '0', rswaveforms_smu_waveform_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
